# Repository lecejeff/RPI_CMx_Carrier (continued)

## KiCad design hardware/rpi_cm4_cm5_CarrierBoard/rpi_cm4_cm5_CarrierBoard.kicad_pcb (continued)

Schematic: DSI_LVDS_bridge.kicad_sch, RPI CMx Carrier

Parts:
C79, C81, C82, C83, C87, C88: 0.1u; CAP_NONPOL_0402; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number GRM155R71H104KE14D
C80, C118: 22u; CAP_NONPOL_0805; Tolerance ±20%; Voltage Rating 25V; Manufacturer Part Number CL21A226MAYNNNE
C89: 1n; CAP_NONPOL_0402; Tolerance ±5%; Voltage Rating 50V; Manufacturer Part Number GRM1555C1H102JA01D; not fitted
Q10, Q11: SSM3K56FS,LF; SC-75; Manufacturer Part Number SSM3K56FS,LF
R91, R92, R93, R94, R100: 10K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0710KL
R95, R96, R97: 0R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-071KL; not fitted
R98, R99, R102, R103: 4K7; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-074K7L
TP26, TP27: 28 mils; SMT_TP_28_MILS; Manufacturer Part Number NA; not fitted
U15: SN65DSI84ZXHR; NFBGA-64; Supply Voltage 1.65V ~ 1.95V; Manufacturer Part Number SN65DSI84ZXHR
U16: SN74LVC1G125DBVR; SOT-23-5; Supply Voltage 1.65V ~ 5.5V; Manufacturer Part Number SN74LVC1G125DBVR

Connections:
1V8_CB: C80.2, C81.2, C82.2, C83.2, C87.2, Q10.1 (G), Q11.1 (G), R95.1, R99.2, R103.2, U15.A9 (VCC), U15.B8 (VCC), U15.D6 (VCC), U15.E5 (VCC), U15.E6 (VCC), U15.F6 (VCC), U15.J2 (VCC); also elsewhere on the board
3V3_CB: C88.2, R98.2, R102.2, U16.5 (VCC); also elsewhere on the board
/DSI1.CLK_N: U15.J5 (DACN); also elsewhere on the board
/DSI1.CLK_P: U15.H5 (DACP); also elsewhere on the board
/DSI1.D0_N: U15.J3 (DA0N); also elsewhere on the board
/DSI1.D0_P: U15.H3 (DA0P); also elsewhere on the board
/DSI1.D1_N: U15.J4 (DA1N); also elsewhere on the board
/DSI1.D1_P: U15.H4 (DA1P); also elsewhere on the board
/DSI1.D2_N: U15.J6 (DA2N); also elsewhere on the board
/DSI1.D2_P: U15.H6 (DA2P); also elsewhere on the board
/DSI1.D3_N: U15.J7 (DA3N); also elsewhere on the board
/DSI1.D3_P: U15.H7 (DA3P); also elsewhere on the board
/DSI - LVDS bridge/LVDS_A.CLK_N: U15.F9 (A_CLKN); also elsewhere on the board
/DSI - LVDS bridge/LVDS_A.CLK_P: U15.F8 (A_CLKP); also elsewhere on the board
/DSI - LVDS bridge/LVDS_A.D0_N: U15.C9 (A_Y0N); also elsewhere on the board
/DSI - LVDS bridge/LVDS_A.D0_P: U15.C8 (A_Y0P); also elsewhere on the board
/DSI - LVDS bridge/LVDS_A.D1_N: U15.D9 (A_Y1N); also elsewhere on the board
/DSI - LVDS bridge/LVDS_A.D1_P: U15.D8 (A_Y1P); also elsewhere on the board
/DSI - LVDS bridge/LVDS_A.D2_N: U15.E9 (A_Y2N); also elsewhere on the board
/DSI - LVDS bridge/LVDS_A.D2_P: U15.E8 (A_Y2P); also elsewhere on the board
/DSI - LVDS bridge/LVDS_A.D3_N: U15.G9 (A_Y3N); also elsewhere on the board
/DSI - LVDS bridge/LVDS_A.D3_P: U15.G8 (A_Y3P); also elsewhere on the board
/DSI - LVDS bridge/SN65DSI_EN: C89.2, R91.1, R92.2, U15.B1 (EN)
/DSI_BRDG_~RST: R100.2, U16.2 (A); also elsewhere on the board
/I2C3.I2C_SCL: Q11.3 (D), R98.1, TP27.1; also elsewhere on the board
/I2C3.I2C_SDA: Q10.3 (D), R102.1, TP26.1; also elsewhere on the board
GND: C79.1, C80.1, C81.1, C82.1, C83.1, C87.1, C88.1, C89.1, C118.1, R92.1, R93.1, R94.1, R100.1, U15.A2 (GND), U15.A8 (GND), U15.B9 (GND), U15.D5 (GND), U15.E4 (GND), U15.F4 (GND), U15.F5 (GND), U15.H9 (GND), U16.1 (~OE), U16.3 (GND); also elsewhere on the board
unnamed: Q10.2 (S), R103.1, U15.J1 (SDA)
unnamed: Q11.2 (S), R99.1, U15.H1 (SCL)
unnamed: R93.2, R95.2, U15.A1 (ADDR)
unnamed: R96.2, U15.J9 (IRQ)
unnamed: R94.2, R97.2, U15.H2 (REFCLK)
unnamed: C79.2, C118.2, U15.J8 (VCORE)
unnamed: R91.2, U16.4 (Y)

Notes on the sheet:
Resistors are 1% 1/16W 0402 unless otherwise noted Capacitors are 10% 50V X7R 0402 unless otherwise noted

Schematic: M2_Expansion.kicad_sch, RPI CMx Carrier

Parts:
C229, C231, C232, C233, C234, C236, C237, C238, C239: 0.1u; CAP_NONPOL_0402; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number GRM155R71H104KE14D
C230, C235: 22u; CAP_NONPOL_0805; Tolerance ±20%; Voltage Rating 25V; Manufacturer Part Number CL21A226MAYNNNE
D11, D18: ESD7016MUTAG; UDFN8; Manufacturer Part Number ESD7016MUTAG
D47: LTST-C190KGKT; LED_0603; Tolerance NA; Manufacturer Part Number LTST-C190KGKT
J23: MDT420M03001; Current Rating 0.5A; Voltage Rating 50V; Manufacturer Part Number MDT420M03001
MTG9: 9774025243R; Manufacturer Part Number 9774025243R
R286: 470R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-07470RL
R288: 22R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0722RL
R289: 10K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0710KL
U38: ASAK-32.768KHZ-LRS-T; 4-SMD_2mmx1_6mm; Tolerance ±25PPM; Supply Voltage 3.3V; Manufacturer Part Number ASAK-32.768KHZ-LRS-T

Connections:
3V3_CB: C229.1, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, C238.2, C239.2, D47.2 (A), J23.2 (3V3), J23.4 (3V3), J23.12 (3V3), J23.14 (3V3), J23.16 (3V3), J23.18 (3V3), J23.70 (3V3), J23.72 (3V3), J23.74 (3V3), U38.4 (VDD); also elsewhere on the board
/M2.CLK_N: D11.7 (I/O5), J23.53 (REFCLK_N); also elsewhere on the board
/M2.CLK_P: D11.8 (I/O6), J23.55 (REFCLK_P); also elsewhere on the board
/M2.RX_N: D11.1 (I/O1), J23.41 (PET0_N); also elsewhere on the board
/M2.RX_P: D11.2 (I/O2), J23.43 (PET0_P); also elsewhere on the board
/M2.TX_N: D11.4 (I/O3), J23.47 (PER0_N); also elsewhere on the board
/M2.TX_P: D11.5 (I/O4), J23.49 (PER0_P); also elsewhere on the board
/M2.~REQ: D18.7 (I/O5), J23.52 (~CLKREQ); also elsewhere on the board
/M2.~RST: D18.5 (I/O4), J23.50 (~PERST); also elsewhere on the board
/M2.~WAKE: D18.8 (I/O6), J23.54 (~PEWAKE); also elsewhere on the board
/M.2_~RST: R289.2, U38.1 (EN); also elsewhere on the board
GND: C229.2, C230.1, C231.1, C232.1, C233.1, C234.1, C235.1, C236.1, C237.1, C238.1, C239.1, D11.3 (VBUS), D11.6 (GND), D18.3 (VBUS), D18.6 (GND), J23.1 (GND), J23.3 (GND), J23.9 (GND), J23.15 (GND), J23.21 (GND), J23.27 (GND), J23.33 (GND), J23.39 (GND), J23.45 (GND), J23.51 (GND), J23.57 (GND), J23.71 (GND), J23.73 (GND), J23.75 (GND), J23.76 (2230), J23.77 (2242), J23.78 (2260), MTG9.1, R289.1, U38.2 (GND); also elsewhere on the board
unnamed: D47.1 (K), R286.2
unnamed: J23.68 (SUSCLK), R288.2
unnamed: J23.10 (~LED1), R286.1
unnamed: R288.1, U38.3 (OUT)

Notes on the sheet:
Resistors are 1% 1/16W 0402 unless otherwise noted Capacitors are 10% 50V X7R 0402 unless otherwise noted

Schematic: MikroBus.kicad_sch, RPI CMx Carrier

Parts:
C195, C199: 1u; CAP_NONPOL_0805; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number CC0805KKX7R9BB105
C196, C198: 10u; CAP_NONPOL_0805; Tolerance ±10%; Voltage Rating 16V; Manufacturer Part Number CL21A106KOQNNNE
C197, C200: 0.1u; CAP_NONPOL_0402; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number GRM155R71H104KE14D
J11: MIKROE-4247; MIKROBUS_SOCKET_TH; Current Rating 3A; Voltage Rating 500V; Manufacturer Part Number MIKROE-4247
R241, R245: 10K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0710KL
R242, R243, R244: 22R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0722RL

Connections:
3V3_CB: C195.2, C196.2, C197.2, J11.7 (+3.3V), R241.2, R245.2; also elsewhere on the board
5V0_CB: C198.2, C199.2, C200.2, J11.10 (+5V); also elsewhere on the board
/MKB1.AN: J11.1 (AN); also elsewhere on the board
/MKB1.INT: R243.1; also elsewhere on the board
/MKB1.MISO: R242.2; also elsewhere on the board
/MKB1.MOSI: J11.6 (MOSI); also elsewhere on the board
/MKB1.PWM: J11.16 (PWM); also elsewhere on the board
/MKB1.RX: R244.1; also elsewhere on the board
/MKB1.SCK: J11.4 (SCK); also elsewhere on the board
/MKB1.SCL: J11.12 (SCL); also elsewhere on the board
/MKB1.SDA: J11.11 (SDA); also elsewhere on the board
/MKB1.TX: J11.13 (TX); also elsewhere on the board
/MKB1.~CS: J11.3 (CS), R245.1; also elsewhere on the board
/MKB1.~RST: J11.2 (RST), R241.1; also elsewhere on the board
GND: C195.1, C196.1, C197.1, C198.1, C199.1, C200.1, J11.8 (GND), J11.9 (GND); also elsewhere on the board
unnamed: J11.15 (INT), R243.2
unnamed: J11.5 (MISO), R242.1
unnamed: J11.14 (RX), R244.2

Notes on the sheet:
Resistors are 1% 1/16W 0402 unless otherwise noted Capacitors are 10% 50V X7R 0402 unless otherwise noted

Schematic: Power Supply.kicad_sch, RPI CMx Carrier

Parts:
C15, C58, C73, C106: 1u; CAP_NONPOL_0603; Tolerance ±10%; Voltage Rating 16V; Manufacturer Part Number CC0603KRX7R7BB105
C56, C62, C69, C70, C71, C72, C168, C169, C170, C187, C188, C189: 0.1u; CAP_NONPOL_0402; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number GRM155R71H104KE14D
C59: 1u; CAP_NONPOL_0805; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number CC0805KKX7R9BB105
C60, C64, C65, C66, C242, C243, C245: 10u; CAP_NONPOL_1210; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number C3225X7R1H106K250AC
C61, C114, C123, C167: 10n; CAP_NONPOL_0402; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number GCM155R71H103KA55D
C172, C178, C179, C180, C181, C182, C183: 22u; CAP_NONPOL_0805; Tolerance ±20%; Voltage Rating 25V; Manufacturer Part Number CL21A226MAYNNNE
C173, C174, C175: 13p; CAP_NONPOL_0402; Tolerance ±2%; Voltage Rating 50V; Manufacturer Part Number GJM1555C1H130GB01D; not fitted
D31: MMSZ5231B; SOD-123; Tolerance ±5%; Manufacturer Part Number MMSZ5231B-7-F
D32: MMSZ5226B; SOD-123; Tolerance ±5%; Manufacturer Part Number MMSZ5226B-7-F
D33: DDZ9678-7; SOD-123; Tolerance ±5%; Manufacturer Part Number DDZ9678-7
L1: PA5003.332NLT; PA5003; Tolerance ±20%; Manufacturer Part Number PA5003.332NLT
L2: PA5003.222NLT; PA5003; Tolerance ±20%; Manufacturer Part Number PA5003.222NLT
L3: PA5003.152NLT; PA5003; Tolerance ±20%; Manufacturer Part Number PA5003.152NLT
Q2, Q3, Q7, Q19, Q20, Q24: 2N7002; SOT-23-3; Manufacturer Part Number 2N7002-7-F
Q22, Q23: SSM3K56FS,LF; SC-75; Manufacturer Part Number SSM3K56FS,LF
R21, R234, R235, R237, R248: 100K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-07100KL
R25, R26, R134, R142, R156, R230, R231, R246, R249, R258, R260, R261, R262: 10K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0710KL
R27: 10K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0710KL; not fitted
R29, R233: 0R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-071KL
R159: 1K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-071KL
R240, R251, R254: 30K1; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0730K1L
R250: 33K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0733KL
R252: 124K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-07124KL
R253: 73K2; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0773K2L
R255, R256, R257: 22K1; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0722K1L
R263, R264, R265: 0R010; RES_SENSE_1206; Tolerance 0.5%; Manufacturer Part Number LVK12R010DER
TP11, TP12, TP13, TP15, TP16, TP17: 28 mils; SMT_TP_28_MILS; Manufacturer Part Number NA; not fitted
U3: SE555DR; SOIC-8-150mil; Supply Voltage 4.5V ~ 18V; Manufacturer Part Number SE555DR
U9, U10, U11: TPS54527DDAR; SO-8-150mil-EP; Input Voltage (Min) 4.5V; Input Voltage (Max) 18V; Manufacturer Part Number TPS54527DDAR
U12: TPS7A7001DDAR; SO-8-150mil-EP; Input Voltage (Min) 1.425V; Input Voltage (Max) 6.5V; Manufacturer Part Number TPS7A7001DDAR
U13, U14, U28: INA180A2IDBVR; SOT-23-5; Offset Voltage 100uV; Supply Voltage 2.7V ~ 5.5V; Manufacturer Part Number INA180A2IDBVR

Connections:
1V05_CB: C172.2, R250.2, R258.2, U12.6 (OUT); also elsewhere on the board
1V8_CB: C72.2, R249.2, R262.2, R265.4 (I), U12.2 (EN), U12.3 (IN); also elsewhere on the board
1V8_CMx: Q22.1 (G), R142.2; also elsewhere on the board
3V3_CB: C187.2, C188.2, C189.2, R261.2, R264.4 (I), U13.5 (VS), U14.5 (VS), U28.5 (VS); also elsewhere on the board
3V3_CMx: Q23.1 (G), R156.2; also elsewhere on the board
5V0_CB: R26.2, R27.2, R134.2, R159.2, R260.2, R263.4 (I); also elsewhere on the board
12V0_CB: C62.2, C64.2, C65.2, C66.2, C69.2, C70.2, C71.2, C242.2, C243.2, C245.2, R235.2, R237.2, R240.2, U3.4 (~RESET), U3.8 (VDD), U9.8 (IN), U10.8 (IN), U11.8 (IN); also elsewhere on the board
/CM4_CM5_CONN_A/~WDOG_IN: R29.2; also elsewhere on the board
/PIC32AK1216/I_1V8_CB: TP13.1, U28.1 (OUT); also elsewhere on the board
/PIC32AK1216/I_3V3_CB: TP12.1, U14.1 (OUT); also elsewhere on the board
/PIC32AK1216/I_5V0_CB: TP11.1, U13.1 (OUT); also elsewhere on the board
/PIC32AK1216/POWER_KILL: R230.2, R231.1; also elsewhere on the board
/Power Supply/CB_LOG_PWR_EN: C58.2, R21.1, R25.2, R246.1, R248.2, TP17.1, U10.1 (EN), U11.1 (EN)
/Power Supply/RPI_5V_EN: Q7.3 (D), R240.1, TP15.1, U9.1 (EN)
/Power Supply/RPI_~PWG: Q22.3 (D), Q24.1 (G), R134.1
/Power Supply/~GO: Q3.1 (G), Q7.1 (G), TP16.1, U3.3 (OUT)
GND: C15.1, C56.1, C58.1, C59.1, C60.1, C61.1, C62.1, C64.1, C65.1, C66.1, C69.1, C70.1, C71.1, C72.1, C73.1, C106.1, C114.1, C123.1, C167.1, C172.1, C178.1, C179.1, C180.1, C181.1, C182.1, C183.1, C187.1, C188.1, C189.1, C242.1, C243.1, C245.1, D31.2 (A), D32.2 (A), D33.2 (A), Q2.2 (S), Q3.2 (S), Q7.2 (S), Q19.2 (S), Q20.2 (S), Q23.2 (S), Q24.2 (S), R142.1, R156.1, R230.1, R234.1, R248.1, R249.1, R251.1, R255.2, R256.2, R257.2, R258.1, R260.1, R261.1, R262.1, U3.1 (GND), U9.5 (GND), U9.9 (EP), U10.5 (GND), U10.9 (EP), U11.5 (GND), U11.9 (EP), U12.8 (GND), U12.9 (EP), U13.2 (GND), U14.2 (GND), U28.2 (GND); also elsewhere on the board
unnamed: C173.2, C178.2, C181.2, D31.1 (K), L1.2, R252.2, R263.1 (I)
unnamed: C174.2, C179.2, C182.2, D32.1 (K), L2.2, R253.2, R264.1 (I)
unnamed: C175.2, C180.2, C183.2, D33.1 (K), L3.2, R254.2, R265.1 (I)
unnamed: Q2.3 (D), R233.1
unnamed: C56.2, Q2.1 (G), R231.2
unnamed: Q3.3 (D), R246.2
unnamed: Q19.3 (D), R25.1
unnamed: Q19.1 (G), Q20.3 (D), R26.1
unnamed: Q20.1 (G), R27.1, R29.1
unnamed: Q22.2 (S), Q23.3 (D)
unnamed: Q24.3 (D), R21.2, R159.1
unnamed: C61.2, U3.5 (CONT)
unnamed: C60.2, R237.1, U3.6 (THRES), U3.7 (DISCH)
unnamed: C59.2, R233.2, R234.2, R235.1, U3.2 (TRIG)
unnamed: C173.1, R252.1, R255.1, U9.2 (FB)
unnamed: C114.2, U9.4 (SS)
unnamed: C168.1, L1.1, U9.6 (SW)
unnamed: C168.2, U9.7 (VBST)
unnamed: C106.2, U9.3 (VREG)
unnamed: C174.1, R253.1, R256.1, U10.2 (FB)
unnamed: C123.2, U10.4 (SS)
unnamed: C169.1, L2.1, U10.6 (SW)
unnamed: C169.2, U10.7 (VBST)
unnamed: C15.2, U10.3 (VREG)
unnamed: C175.1, R254.1, R257.1, U11.2 (FB)
unnamed: C167.2, U11.4 (SS)
unnamed: C170.1, L3.1, U11.6 (SW)
unnamed: C170.2, U11.7 (VBST)
unnamed: C73.2, U11.3 (VREG)
unnamed: R250.1, R251.2, U12.7 (FB)
unnamed: R263.2 (V), U13.3 (IN+)
unnamed: R263.3 (V), U13.4 (IN-)
unnamed: R264.2 (V), U14.3 (IN+)
unnamed: R264.3 (V), U14.4 (IN-)
unnamed: R265.2 (V), U28.3 (IN+)
unnamed: R265.3 (V), U28.4 (IN-)

Notes on the sheet:
If 3V3_CMx and 1V8_CMX are OK, release CB rails
Pulled high at CMx to +5V (100K PU) Reset power supplies due to WDOG when shutdown is issued from OS
Resistors are 1% 1/16W 0402 unless otherwise noted Capacitors are 10% 50V X7R 0402 unless otherwise noted

Schematic: CM4_CM5_CONN_A.kicad_sch, RPI CMx Carrier

Parts:
C67, C68, C76, C77, C78, C108: 22u; CAP_NONPOL_0805; Tolerance ±20%; Voltage Rating 25V; Manufacturer Part Number CL21A226MAYNNNE
C74, C100, C102, C107, C109, C111, C113, C115, C116: 0.1u; CAP_NONPOL_0402; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number GRM155R71H104KE14D
C104, C105: 10p; CAP_NONPOL_0402; Tolerance ±5%; Voltage Rating 50V; Manufacturer Part Number CC0402JRNPO9BN100
D16: BAT42WS-TP; SOD-323; Tolerance NA; Manufacturer Part Number BAT42WS-TP
J7: 2998TR; Manufacturer Part Number 2998TR
J19: RPI_CMx_A; DF40HC(3.0)-100DS-0.4V; Current Rating 0.5A; Voltage Rating 150V; Manufacturer Part Number DF40HC(3.0)-100DS-0.4V(58)
Q12: 2N7002; SOT-23-3; Manufacturer Part Number 2N7002-7-F
R2, R20, R115, R118, R121, R125, R126, R137, R139, R140, R141, R143, R146, R148, R154, R155: 22R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0722RL
R19, R112, R116, R119, R147: 10K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0710KL
R83, R111, R124, R127: 4K7; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-074K7L
R113, R132, R138: 10K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0710KL; not fitted
R151: 0R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-071KL; not fitted
R152: 0R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-071KL
R158: 30K1; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0730K1L
TP22, TP23, TP24, TP25: 28 mils; SMT_TP_28_MILS; Manufacturer Part Number NA; not fitted
U19: SN74LVC1G125DBVR; SOT-23-5; Supply Voltage 1.65V ~ 5.5V; Manufacturer Part Number SN74LVC1G125DBVR
U21: MCP7940NT-I/MS; MSOP-8; Supply Voltage 1.8V ~ 5.5V; Manufacturer Part Number MCP7940NT-I/MS
Y2: 32.768kHz; 2-SMD_3_2mmx1_5mm; Tolerance ±20ppm; Manufacturer Part Number ABS07-32.768KHZ-7-T

Connections:
1V8_CMx: C76.2, C111.2, J19.88 (CM4_1V8_OUT), J19.90 (CM4_1V8_OUT); also elsewhere on the board
3V3_CB: C107.1, D16.2 (A), R19.2, R83.2, R111.2, R112.2, R124.2, R127.2, R138.2, R151.2, U21.8 (VDD); also elsewhere on the board
3V3_CMx: C77.2, C102.2, C109.2, J19.84 (CM4_3V3_OUT), J19.86 (CM4_3V3_OUT), R152.2, U19.5 (VCC); also elsewhere on the board
5V0_CB: C67.2, C68.2, C74.2, C78.2, C108.2, C113.2, C115.2, C116.2, J19.77 (+5V), J19.79 (+5V), J19.81 (+5V), J19.83 (+5V), J19.85 (+5V), J19.87 (+5V), R132.2; also elsewhere on the board
/CM4_CM5_CONN_A/CM4_~CM5_BUILD: J19.29 (GPIO16), R112.1, R113.2; also elsewhere on the board
/CM4_CM5_CONN_A/CMx_INT: J19.37 (GPIO7), R119.2; also elsewhere on the board
/CM4_CM5_CONN_A/EXT_~RST: R155.2, TP22.1; also elsewhere on the board
/CM4_CM5_CONN_A/GPIO6: J19.30 (GPIO6), R143.1
/CM4_CM5_CONN_A/GPIO8: J19.39 (GPIO8), R121.1
/CM4_CM5_CONN_A/GPIO10: J19.44 (GPIO10), R148.1
/CM4_CM5_CONN_A/GPIO11: J19.38 (GPIO11), R146.1
/CM4_CM5_CONN_A/GPIO12: J19.31 (GPIO12), R118.1
/CM4_CM5_CONN_A/GPIO13: J19.28 (GPIO13), R20.1
/CM4_CM5_CONN_A/GPIO14: J19.55 (GPIO14), R126.1
/CM4_CM5_CONN_A/GPIO18: J19.49 (GPIO18), R125.1
/CM4_CM5_CONN_A/GPIO19: J19.26 (GPIO19), R141.1
/CM4_CM5_CONN_A/GPIO21: J19.25 (GPIO21), R115.1
/CM4_CM5_CONN_A/GPIO26: J19.24 (GPIO26), R140.1
/CM4_CM5_CONN_A/GPIO27: J19.48 (GPIO27), R2.1
/CM4_CM5_CONN_A/GPIO35: J19.100 (~EXTRST/GPIO35), R154.1
/CM4_CM5_CONN_A/GPIO_VREF: J19.78 (GPIO_VREF), R151.1, R152.1
/CM4_CM5_CONN_A/PIC_INT: R143.2, TP25.1; also elsewhere on the board
/CM4_CM5_CONN_A/PI_LED_~ACT: J19.21 (~PI_LED_ACT); also elsewhere on the board
/CM4_CM5_CONN_A/PPS_OUT: J19.50 (GPIO17), R19.1, TP23.1, U21.7 (MFP); also elsewhere on the board
/CM4_CM5_CONN_A/PWM_0: R118.2; also elsewhere on the board
/CM4_CM5_CONN_A/RPI_LED_~PWR: J19.95 (~PI_LED_PWR); also elsewhere on the board
/CM4_CM5_CONN_A/RXD0: J19.51 (GPIO15), R138.1; also elsewhere on the board
/CM4_CM5_CONN_A/TXD0: R126.2; also elsewhere on the board
/CM4_CM5_CONN_A/~WDOG_IN: J19.99 (GLOBAL_EN/PMIC_EN), R132.1; also elsewhere on the board
/ETH_P0_N: J19.10 (ETH_P0_N); also elsewhere on the board
/ETH_P0_P: J19.12 (ETH_P0_P); also elsewhere on the board
/ETH_P1_N: J19.6 (ETH_P1_N); also elsewhere on the board
/ETH_P1_P: J19.4 (ETH_P1_P); also elsewhere on the board
/ETH_P2_N: J19.9 (ETH_P2_N); also elsewhere on the board
/ETH_P2_P: J19.11 (ETH_P2_P); also elsewhere on the board
/ETH_P3_N: J19.5 (ETH_P3_N); also elsewhere on the board
/ETH_P3_P: J19.3 (ETH_P3_P); also elsewhere on the board
/ETH_~LED1: J19.19 (~ETH_LED1/FAN_PWM); also elsewhere on the board
/ETH_~LED2: J19.17 (~ETH_LED2); also elsewhere on the board
/ETH_~LED3: J19.15 (~ETH_LED3); also elsewhere on the board
/I2C0.I2C_SCL: J19.80 (SCL0); also elsewhere on the board
/I2C0.I2C_SDA: J19.82 (SDA0); also elsewhere on the board
/I2C3.I2C_SCL: J19.34 (GPIO5), R127.1, U21.6 (SCL); also elsewhere on the board
/I2C3.I2C_SDA: J19.54 (GPIO4), R83.1, U21.5 (SDA); also elsewhere on the board
/I2C6.I2C_SCL: J19.47 (GPIO23), R124.1; also elsewhere on the board
/I2C6.I2C_SDA: J19.46 (GPIO22), R111.1; also elsewhere on the board
/I2S_COFS: R141.2; also elsewhere on the board
/I2S_DIN: J19.27 (GPIO20), R116.2; also elsewhere on the board
/I2S_DOUT: R115.2; also elsewhere on the board
/I2S_SCLK: R125.2; also elsewhere on the board
/MIPI0_GPIO: J19.97 (CAM_GPIO/GPIO34); also elsewhere on the board
/SDIO_CLK: J19.57 (SD_CLK); also elsewhere on the board
/SDIO_CMD: J19.62 (SD_CMD); also elsewhere on the board
/SDIO_D0: J19.63 (SD_DAT0); also elsewhere on the board
/SDIO_D1: J19.67 (SD_DAT1); also elsewhere on the board
/SDIO_D2: J19.69 (SD_DAT2); also elsewhere on the board
/SDIO_D3: J19.61 (SD_DAT3); also elsewhere on the board
/SD_PWR_ON: R137.2; also elsewhere on the board
/SPI2.SPI_CLK: R146.2; also elsewhere on the board
/SPI2.SPI_MISO: J19.40 (GPIO9), R147.2; also elsewhere on the board
/SPI2.SPI_MOSI: R148.2; also elsewhere on the board
/SPI2.SPI_~CS: R121.2; also elsewhere on the board
/USB_OTG.OTG_ID: R139.2; also elsewhere on the board
GND: C67.1, C68.1, C74.1, C76.1, C77.1, C78.1, C100.1, C102.1, C104.2, C105.2, C107.2, C108.1, C109.1, C111.1, C113.1, C115.1, C116.1, J7.2, J19.1 (GND), J19.2 (GND), J19.7 (GND), J19.8 (GND), J19.13 (GND), J19.14 (GND), J19.22 (GND), J19.23 (GND), J19.32 (GND), J19.33 (GND), J19.42 (GND), J19.43 (GND), J19.52 (GND), J19.53 (GND), J19.59 (GND), J19.60 (GND), J19.65 (GND), J19.66 (GND), J19.71 (GND), J19.74 (GND), J19.98 (GND), Q12.2 (S), R113.1, R116.1, R119.1, R147.1, U19.1 (~OE), U19.3 (GND), U21.4 (GND); also elsewhere on the board
unnamed: D16.1 (K), R158.2
unnamed: J19.75 (SD_PWR_ON), R137.1
unnamed: J19.93 (~RPIBOOT), Q12.3 (D)
unnamed: C100.2, Q12.1 (G), R139.1
unnamed: R154.2, U19.2 (A)
unnamed: R155.1, U19.4 (Y)
unnamed: J7.1, R158.1, TP24.1, U21.3 (VBAT)
unnamed: C104.1, U21.1 (X1), Y2.2 (XO)
unnamed: C105.1, U21.2 (X2), Y2.1 (XI)

Notes on the sheet:
INT 1K8 PU 3V3_CMx
PU = CM4 PD = CM5
PU'd at DSI bridge
Resistors are 1% 1/16W 0402 unless otherwise noted Capacitors are 10% 50V X7R 0402 unless otherwise noted
INT 10K PU 3V3_CMx
10K PD @ USB MUX OTG = USB BOOT OTHERWISE eMMC
3.0V 6.8mm
INT 100K PU +5V

Schematic: HDMI.kicad_sch, RPI CMx Carrier

Parts:
C90, C91, C92, C94: 0.1u; CAP_NONPOL_0402; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number GRM155R71H104KE14D
C93: 22u; CAP_NONPOL_0805; Tolerance ±20%; Voltage Rating 25V; Manufacturer Part Number CL21A226MAYNNNE
D12, D15: ESD7016MUTAG; UDFN8; Manufacturer Part Number ESD7016MUTAG
J4: 2086581001; Current Rating 0.5A; Voltage Rating 40V; Manufacturer Part Number 2086581001
R101: 0R; RES_0603; Tolerance 1%; Manufacturer Part Number RC0603JR-070RL
R104, R105: 10K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0710KL
U18: AP22913W6-7; SOT-23-6; Load Voltage 1.5V ~ 5.5V; Manufacturer Part Number AP22913W6-7

Connections:
5V0_CB: C90.2, U18.4 (IN), U18.6 (IN); also elsewhere on the board
/HDMI0.CEC: D12.4 (I/O3), J4.13 (CEC); also elsewhere on the board
/HDMI0.CLK_N: D12.2 (I/O2), J4.12 (CK-); also elsewhere on the board
/HDMI0.CLK_P: D12.1 (I/O1), J4.10 (CK+); also elsewhere on the board
/HDMI0.D0_N: D15.8 (I/O6), J4.9 (D0-); also elsewhere on the board
/HDMI0.D0_P: D15.7 (I/O5), J4.7 (D0+); also elsewhere on the board
/HDMI0.D1_N: D15.5 (I/O4), J4.6 (D1-); also elsewhere on the board
/HDMI0.D1_P: D15.4 (I/O3), J4.4 (D1+); also elsewhere on the board
/HDMI0.D2_N: D15.2 (I/O2), J4.3 (D2-); also elsewhere on the board
/HDMI0.D2_P: D15.1 (I/O1), J4.1 (D2+); also elsewhere on the board
/HDMI0.HPD: D12.8 (I/O6), J4.19 (HPD); also elsewhere on the board
/HDMI0.SCL: D12.5 (I/O4), J4.15 (SCL); also elsewhere on the board
/HDMI0.SDA: D12.7 (I/O5), J4.16 (SDA); also elsewhere on the board
/HDMI/5V_HDMI0: C91.2, C92.2, C93.2, C94.2, D12.3 (VBUS), D15.3 (VBUS), J4.18 (5V), R105.2, U18.1 (OUT)
/HDMI_~RST: R104.2, U18.3 (EN); also elsewhere on the board
CGND: J4.20 (MT1), J4.21 (MT2), J4.22 (MT3), J4.23 (MT4), R101.1; also elsewhere on the board
GND: C90.1, C91.1, C92.1, C93.1, C94.1, D12.6 (GND), D15.6 (GND), J4.2 (D2S), J4.5 (D1S), J4.8 (D0S), J4.11 (CKS), J4.17 (GND), R101.2, R104.1, R105.1, U18.2 (GND), U18.5 (GND); also elsewhere on the board

Notes on the sheet:
Resistors are 1% 1/16W 0402 unless otherwise noted Capacitors are 10% 50V X7R 0402 unless otherwise noted

Schematic: Ethernet.kicad_sch, RPI CMx Carrier

Parts:
C95, C96, C97, C98: 0.1u; CAP_NONPOL_0402; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number GRM155R71H104KE14D
D13, D14: ESD7016MUTAG; UDFN8; Manufacturer Part Number ESD7016MUTAG
J5: 0826-1X1T-32-F; Current Rating NA; Voltage Rating NA; Manufacturer Part Number 0826-1X1T-32-F
R106: 0R; RES_0603; Tolerance 1%; Manufacturer Part Number RC0603JR-070RL
R107, R108: 470R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-07470RL
R109: 0R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-071KL; not fitted

Connections:
3V3_CB: R107.1, R108.1; also elsewhere on the board
/ETH_P0_N: D13.4 (I/O3), J5.10 (TRD1-); also elsewhere on the board
/ETH_P0_P: D13.5 (I/O4), J5.11 (TRD1+); also elsewhere on the board
/ETH_P1_N: D13.2 (I/O2), J5.5 (TRD2-); also elsewhere on the board
/ETH_P1_P: D13.1 (I/O1), J5.4 (TRD2+); also elsewhere on the board
/ETH_P2_N: D14.7 (I/O5), J5.2 (TRD3-); also elsewhere on the board
/ETH_P2_P: D14.8 (I/O6), J5.3 (TRD3+); also elsewhere on the board
/ETH_P3_N: D14.5 (I/O4), J5.9 (TRD4-); also elsewhere on the board
/ETH_P3_P: D14.4 (I/O3), J5.8 (TRD4+); also elsewhere on the board
/ETH_~LED1: D13.8 (I/O6), R109.1; also elsewhere on the board
/ETH_~LED2: D14.1 (I/O1), J5.13 (LED_Y_K); also elsewhere on the board
/ETH_~LED3: D13.7 (I/O5), J5.15 (LED_GK_OA); also elsewhere on the board
CGND: J5.17, J5.18, R106.2; also elsewhere on the board
GND: C95.1, C96.1, C97.1, C98.1, D13.3 (VBUS), D13.6 (GND), D14.3 (VBUS), D14.6 (GND), R106.1; also elsewhere on the board
unnamed: J5.16 (LED_GA_OK), R108.2, R109.2
unnamed: J5.14 (LED_Y_A), R107.2
unnamed: C95.2, J5.12 (TRCT1)
unnamed: C96.2, J5.6 (TRCT2)
unnamed: C97.2, J5.1 (TRCT3)
unnamed: C98.2, J5.7 (TRCT4)

Notes on the sheet:
Resistors are 1% 1/16W 0402 unless otherwise noted Capacitors are 10% 50V X7R 0402 unless otherwise noted

Schematic: RESET_SUPERVISOR.kicad_sch, RPI CMx Carrier

Parts:
C191, C192, C193, C201: 1n; CAP_NONPOL_0402; Tolerance ±5%; Voltage Rating 50V; Manufacturer Part Number GRM1555C1H102JA01D
C202, C218, C221: 0.1u; CAP_NONPOL_0402; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number GRM155R71H104KE14D
D34: LTST-C190KGKT; LED_0603; Tolerance NA; Manufacturer Part Number LTST-C190KGKT
Q8, Q9, Q13: 2N7002; SOT-23-3; Manufacturer Part Number 2N7002-7-F
R90, R122, R123, R281, R307, R308, R309, R310, R311, R312, R313, R314: 22R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0722RL
R267: 1K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-071KL
R268, R269, R270, R271, R272: 10K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0710KL
R273: 470R; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-07470RL
TP1, TP2, TP3, TP4, TP5, TP6, TP7: 28 mils; SMT_TP_28_MILS; Manufacturer Part Number NA; not fitted
U30: STM6710DWB6F; SOT-23-6; Supply Voltage 1.20V ~ 5.5V; Manufacturer Part Number STM6710DWB6F
U31: SN74LVC1G125DBVR; SOT-23-5; Supply Voltage 1.65V ~ 5.5V; Manufacturer Part Number SN74LVC1G125DBVR
U32, U35: SN74HCS365QPWRQ1; TSSOP-16-5.8mm; Supply Voltage 2.0V ~ 6.0V; Manufacturer Part Number SN74HCS365QPWRQ1

Connections:
1V05_CB: R267.2, TP4.1; also elsewhere on the board
1V8_CB: C192.2, TP5.1, U30.3 (V3IN); also elsewhere on the board
3V3_CB: C193.2, C202.2, C218.1, C221.1, R269.2, R271.2, R272.2, TP6.1, U30.2 (V2IN), U31.5 (VCC), U32.16 (VCC), U35.16 (VCC); also elsewhere on the board
5V0_CB: C201.2, TP7.1, U30.1 (V1IN); also elsewhere on the board
/CM4_CM5_CONN_A/EXT_~RST: Q9.1 (G), R270.2, TP2.1; also elsewhere on the board
/CODEC_~RST: R310.2; also elsewhere on the board
/DSI_BRDG_~RST: R314.2; also elsewhere on the board
/EXP_MIPI_~RST: R307.2; also elsewhere on the board
/HDMI_~RST: R308.2; also elsewhere on the board
/M.2_~RST: R312.2; also elsewhere on the board
/PIC_~RST: R313.2; also elsewhere on the board
/RESET_SUPERVISOR/PWG: Q8.1 (G), R269.1, TP1.1, U30.6 (~RESET), U31.2 (A)
/TFT_POWER_~RST: R123.2; also elsewhere on the board
/USB_HUB_~RST: R309.2; also elsewhere on the board
GND: C191.1, C192.1, C193.1, C201.1, C202.1, C218.2, C221.2, D34.1 (K), Q9.2 (S), Q13.2 (S), R268.1, R270.1, U30.5 (GND), U31.1 (~OE), U31.3 (GND), U32.1 (~OE1), U32.8 (GND), U32.15 (~OE2), U35.1 (~OE1), U35.8 (GND), U35.15 (~OE2); also elsewhere on the board
unnamed: D34.2 (A), R273.2
unnamed: Q8.2 (S), Q9.3 (D)
unnamed: Q13.3 (D), R272.1, TP3.1, U32.2 (A1), U32.4 (A2), U32.6 (A3), U32.10 (A4), U32.12 (A5), U32.14 (A6), U35.2 (A1), U35.4 (A2), U35.6 (A3), U35.10 (A4), U35.12 (A5), U35.14 (A6)
unnamed: Q8.3 (D), Q13.1 (G), R271.1
unnamed: C191.2, R267.1, R268.2, U30.4 (V4IN)
unnamed: R273.1, U31.4 (Y)
unnamed: R281.1, U32.3 (Y1)
unnamed: R90.1, U32.5 (Y2)
unnamed: R122.1, U32.7 (Y3)
unnamed: R123.1, U32.9 (Y4)
unnamed: R307.1, U32.11 (Y5)
unnamed: R308.1, U32.13 (Y6)
unnamed: R309.1, U35.3 (Y1)
unnamed: R310.1, U35.5 (Y2)
unnamed: R311.1, U35.7 (Y3)
unnamed: R312.1, U35.9 (Y4)
unnamed: R313.1, U35.11 (Y5)
unnamed: R314.1, U35.13 (Y6)

Notes on the sheet:
ON = PWR OK OFF = PWR FAIL
EXT_RSTn : Driven low during reset, high when CMx has started booting Push-Pull output If Pi not present (float), hold SYS_~{RST} low Buffer powered by 3V3_CM4
Resistors are 1% 1/16W 0402 unless otherwise noted Capacitors are 10% 50V X7R 0402 unless otherwise noted

Schematic: USB-C & EXP MIPI.kicad_sch, RPI CMx Carrier

Parts:
C117, C119, C121, C122: 0.1u; CAP_NONPOL_0402; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part Number GRM155R71H104KE14D
C120: 22u; CAP_NONPOL_0805; Tolerance ±20%; Voltage Rating 25V; Manufacturer Part Number CL21A226MAYNNNE
D17, D19: ESD7016MUTAG; UDFN8; Manufacturer Part Number ESD7016MUTAG
D20, D35: D1213A-02SOL-7; SOT-23-3; Manufacturer Part Number D1213A-02SOL-7
J16: 12401598E4#2A; Current Rating 5A; Voltage Rating 100V; Manufacturer Part Number 12401598E4#2A
J17: 5051102291; Current Rating 0.5A; Voltage Rating 50V; Manufacturer Part Number 5051102291
R181, R182: 5K1; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-075K1L
R184, R215: 10K; RES_0402; Tolerance 1%; Manufacturer Part Number RC0402FR-0710KL
U23: AP22913W6-7; SOT-23-6; Load Voltage 1.5V ~ 5.5V; Manufacturer Part Number AP22913W6-7

Connections:
3V3_CB: C117.2, U23.4 (IN), U23.6 (IN); also elsewhere on the board
/EXP_MIPI_~RST: R184.2, U23.3 (EN); also elsewhere on the board
/I2C0.I2C_SCL: D19.7 (I/O5), J17.3; also elsewhere on the board
/I2C0.I2C_SDA: D19.8 (I/O6), J17.2; also elsewhere on the board
/MIPI0.CLK_N: D17.7 (I/O5), J17.15; also elsewhere on the board
/MIPI0.CLK_P: D17.8 (I/O6), J17.14; also elsewhere on the board
/MIPI0.D0_N: D17.1 (I/O1), J17.21; also elsewhere on the board
/MIPI0.D0_P: D17.2 (I/O2), J17.20; also elsewhere on the board
/MIPI0.D1_N: D17.4 (I/O3), J17.18; also elsewhere on the board
/MIPI0.D1_P: D17.5 (I/O4), J17.17; also elsewhere on the board
/MIPI0.D2_N: D19.1 (I/O1), J17.12; also elsewhere on the board
/MIPI0.D2_P: D19.2 (I/O2), J17.11; also elsewhere on the board
/MIPI0.D3_N: D19.4 (I/O3), J17.9; also elsewhere on the board
/MIPI0.D3_P: D19.5 (I/O4), J17.8; also elsewhere on the board
/MIPI0_GPIO: J17.6; also elsewhere on the board
/USB-C & EXP MIPI/3V3_MIPI0: C119.2, C120.2, C121.2, C122.2, D17.3 (VBUS), D19.3 (VBUS), J17.1, R215.2, U23.1 (OUT)
/USB_OTG.OTG_ID: D20.1, J16.A4 (VBUS), J16.A9 (VBUS), J16.B4 (VBUS), J16.B9 (VBUS); also elsewhere on the board
/USB_OTG.USB_N: D35.2 (A), J16.A7 (D-), J16.B7 (D-); also elsewhere on the board
/USB_OTG.USB_P: D35.1, J16.A6 (D+), J16.B6 (D+); also elsewhere on the board
GND: C117.1, C119.1, C120.1, C121.1, C122.1, D17.6 (GND), D19.6 (GND), D20.3 (GND), D35.3 (GND), J16.A1 (GND), J16.A12 (GND), J16.B1 (GND), J16.B12 (GND), J16.C1 (SHLD), J17.4, J17.7, J17.10, J17.13, J17.16, J17.19, J17.22, R181.1, R182.1, R184.1, R215.1, U23.2 (GND), U23.5 (GND); also elsewhere on the board
unnamed: J16.A5 (CC1), R181.2
unnamed: J16.B5 (CC2), R182.2

Notes on the sheet:
Resistors are 1% 1/16W 0402 unless otherwise noted Capacitors are 10% 50V X7R 0402 unless otherwise noted
